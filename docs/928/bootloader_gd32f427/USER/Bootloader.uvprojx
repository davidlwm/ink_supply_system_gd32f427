# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: fromelf --bin !L --output ..\OBJ\Bootloader.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F427,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\config;..\bootloader;..\utils
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c gd32f4xx_it.c system_gd32f4xx.c
  group BOOTLOADER
    ../bootloader/: bootloader.c boot_config.c
  group UTILS
    ../utils/: crc32.c flash_hal.c
  group CORE
    ../CORE/: startup_gd32f407xx.s

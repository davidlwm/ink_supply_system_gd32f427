# Keil uVision project InkSupplySystem.uvprojx, settings and files
target IIC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\lib\CMSIS;..\OBJ;..\USER;..\USMART;..\middleware\delay;..\middleware\sys;..\middleware\usart;..\lib\STM32F4xx_HAL_Driver\Inc;..\drivers\LED;..\drivers\KEY;..\drivers\LCD;..\drivers\24CXX;..\drivers\IIC;..\drivers\ADC;..\drivers\DAC;..\drivers\DMA;..\drivers\SPI;..\drivers\W25QXX;..\drivers\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c gd32f4xx_it.c system_gd32f4xx.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group README
    ../: readme.txt
  group Drivers
    ../Drivers/LED/: led.c
    ../Drivers/LCD/: lcd.c
    ../Drivers/KEY/: key.c
    ../Drivers/IIC/: myiic.c
    ../Drivers/24CXX/: 24cxx.c
    ../drivers/ADC/: adc.c
    ../drivers/DAC/: dac.c
    ../drivers/DMA/: dma.c
    ../drivers/SPI/: spi.c
    ../drivers/W25QXX/: w25qxx.c
    ../drivers/TIMER/: timer.c
  group middleware
    ../middleware/delay/: delay.c
    ../middleware/sys/: sys.c
    ../middleware/usart/: usart.c
  group STM32Hal
    ../lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dac_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c
  group CMSIS
    ../lib/CMSIS/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_gd32f407xx.s
